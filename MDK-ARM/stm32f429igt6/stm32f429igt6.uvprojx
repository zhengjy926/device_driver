# Keil uVision project stm32f429igt6.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f429igt6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=25000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNAL_CLOCK_VALUE=12288000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32F429xx
  c include: ..\..\third_party\stm32f4xx-hal-driver\Inc;..\..\third_party\stm32f4xx-hal-driver\Inc\Legacy;..\..\third_party\CMSIS_6\CMSIS\Core\Include;..\..\third_party\CMSIS_6\CMSIS\Core\Include\m-profile;..\..\third_party\cmsis-device-f4\Include;..\..\drivers\gpio;..\..\lib
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ../../app/: main.c
  group drivers
    ../../drivers/gpio/: gpio_stm32.c
  group third_party/stm32f4xx_hal
    ../../third_party/stm32f4xx-hal-driver/Src/: stm32f4xx_ll_exti.c stm32f4xx_ll_gpio.c stm32f4xx_ll_rcc.c stm32f4xx_ll_utils.c
  group third_party/cmsis
    ../../third_party/cmsis-device-f4/Source/Templates/: system_stm32f4xx.c
    ../../third_party/cmsis-device-f4/Source/Templates/arm/: startup_stm32f429xx.s
